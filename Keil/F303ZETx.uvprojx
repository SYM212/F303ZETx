# Keil uVision project F303ZETx.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303ZETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: F303ZETx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ..\Start;..\Library;..\Periph;..\Hardware;..\System;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Start
    ../Start/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f30x.h system_stm32f30x.c system_stm32f30x.h arm_cortexM4lf_math.lib
    ../Start/ARM/: startup_stm32f303xe.s
  group Library
    ../Library/: stm32f30x_adc.c stm32f30x_adc.h stm32f30x_can.c stm32f30x_can.h stm32f30x_comp.c stm32f30x_comp.h stm32f30x_crc.c stm32f30x_crc.h stm32f30x_dac.c stm32f30x_dac.h stm32f30x_dbgmcu.c stm32f30x_dbgmcu.h stm32f30x_dma.c stm32f30x_dma.h stm32f30x_exti.c stm32f30x_exti.h stm32f30x_flash.c stm32f30x_flash.h stm32f30x_fmc.c stm32f30x_fmc.h stm32f30x_gpio.c stm32f30x_gpio.h stm32f30x_hrtim.c stm32f30x_hrtim.h stm32f30x_i2c.c stm32f30x_i2c.h stm32f30x_iwdg.c stm32f30x_iwdg.h stm32f30x_misc.c stm32f30x_misc.h stm32f30x_opamp.c stm32f30x_opamp.h stm32f30x_pwr.c stm32f30x_pwr.h stm32f30x_rcc.c stm32f30x_rcc.h stm32f30x_rtc.c stm32f30x_rtc.h stm32f30x_spi.c stm32f30x_spi.h stm32f30x_syscfg.c stm32f30x_syscfg.h stm32f30x_tim.c stm32f30x_tim.h stm32f30x_usart.c stm32f30x_usart.h stm32f30x_wwdg.c stm32f30x_wwdg.h
  group User
    ../User/: main.c main.h stm32f30x_conf.h stm32f30x_it.c stm32f30x_it.h
